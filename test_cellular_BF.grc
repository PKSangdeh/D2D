<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cent_freq</value></param>
<param><key>value</key><value>2100000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.5</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.5</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.5</value></param>
<param><key>step</key><value>0.02</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0_0</value></param>
<param><key>const</key><value>phase_offset3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0_0_0</value></param>
<param><key>const</key><value>phase_offset2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0_0_1</value></param>
<param><key>const</key><value>phase_offset1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1_0_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/sdr/Desktop/Pedram/D2D_wo_ext_clk/signals/user_rx_2.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_0_0</value></param>
<param><key>file</key><value>/home/sdr/Desktop/Pedram/D2D_wo_ext_clk/signals/nr_bf_tx_0.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_0_0_0</value></param>
<param><key>file</key><value>/home/sdr/Desktop/Pedram/D2D_wo_ext_clk/signals/nr_bf_tx_1.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_0_0_0_0</value></param>
<param><key>file</key><value>/home/sdr/Desktop/Pedram/D2D_wo_ext_clk/signals/nr_bf_tx_2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_0_0_0_0_0</value></param>
<param><key>file</key><value>/home/sdr/Desktop/Pedram/D2D_wo_ext_clk/signals/nr_bf_tx_3.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_0_0_0</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_0_0_0_0</value></param>
</block>
<block>
<key>blocks_magphase_to_complex</key>
<param><key>id</key><value>blocks_magphase_to_complex_0_0_0_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0_0</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0_1</value></param>
<param><key>const</key><value>const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>num_items</key><value>1*samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>cent_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>name</key><value>"177"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>cent_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>bw1</key><value>bandwidth</value></param>
<param><key>center_freq1</key><value>cent_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>rf_gain</value></param>
<param><key>ant2</key><value>TX/RX</value></param>
<param><key>bw2</key><value>bandwidth</value></param>
<param><key>center_freq2</key><value>cent_freq</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>rf_gain</value></param>
<param><key>ant3</key><value></value></param>
<param><key>bw3</key><value>bandwidth</value></param>
<param><key>center_freq3</key><value>cent_freq</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.1.175, addr1=192.168.1.176,addr2=192.168.1.177,addr3=192.168.1.178"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>clock_source2</key><value>external</value></param>
<param><key>time_source2</key><value>external</value></param>
<param><key>clock_source3</key><value>external</value></param>
<param><key>time_source3</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>cent_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>28</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.1.185"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_const_source_x_0_0_0_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0_0_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0_0_1</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_0_0</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1_0_1</source_block_id><sink_block_id>blocks_magphase_to_complex_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_magphase_to_complex_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
